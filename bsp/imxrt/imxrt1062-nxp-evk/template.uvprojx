# Keil uVision project template.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.12.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -xc -std=gnu99 -mimplicit-float -Wno-implicit-function-declaration -Wno-incompatible-function-pointer-types -Wno-absolute-value
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
