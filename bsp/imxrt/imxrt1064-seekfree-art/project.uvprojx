# Keil uVision project project.uvprojx, settings and files
target debug_flash (6150000::V6.15::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) IROM2(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_BOOT_HEADER_ENABLE=1,XIP_BOOT_HEADER_DCD_ENABLE=1,ARM_MATH_CM7,__FPU_PRESENT,FFCONF_H="oofatfs/ffconf.h",HARD_FP,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, STD=C99, ENDIANNESS, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL, CPU_MIMXRT1062DVL6A, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: -xc -std=gnu99 -mimplicit-float -Wno-implicit-function-declaration -Wno-incompatible-function-pointer-types -Wno-absolute-value
  c include: applications;..\components\openmv-nxp\cmsisinclude;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\MCUX_Config;board\ports;..\libraries\drivers;..\libraries\drivers\config;..\libraries\drivers\wlan\esp8266;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\dfs\filesystems\ramfs;..\..\..\components\finsh;.;..\..\..\include;..\libraries\lcd;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\libraries\MIMXRT1062\CMSIS\Include;..\libraries\MIMXRT1062\MIMXRT1062;..\libraries\MIMXRT1062\MIMXRT1062\drivers;..\components\micropython-nxp\lib\lv_binding_micropython;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src\lv_core;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src\lv_draw;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src\lv_font;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src\lv_gpu;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src\lv_hal;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src\lv_misc;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src\lv_thems;..\components\micropython-nxp\lib\lv_binding_micropython\lvgl\src\lv_widgets;..\components\micropython-nxp\lib\lv_binding_micropython\driver\nxp;..\components\micropython-nxp\lib\lv_binding_micropython\driver\png\lodepng;..\components\micropython-nxp;..\components\micropython-nxp\port;..\components\micropython-nxp\port\modules;..\components\micropython-nxp\port\modules\machine;..\components\micropython-nxp\lib\aia_cmm;..\components\micropython-nxp\lib\aia_doc;..\components\openmv-nxp\omv;..\components\openmv-nxp\omv\img;..\components\openmv-nxp\omv\nn;..\components\openmv-nxp\omv\py;..\components\openmv-nxp\cmsis\include;..\components\openmv-nxp\nncu;..\components\openmv-nxp\libtf\cortex-m7;..\components\openmv-nxp\glow;..\libraries\sensors;..\..\..\components\drivers\touch;..\..\..\components\drivers\include;..\libraries\drivers\usb;..\libraries\drivers\usb\config;..\libraries\drivers\usb\app;..\libraries\drivers\usb\include;..\libraries\drivers\usb\phy;..\libraries\drivers\usb\device;..\libraries\drivers\usb\omv;xip
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Applications
    applications/: main.c
  group cmsis
    ../components/openmv-nxp/cmsis/src/dsp/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ../components/openmv-nxp/cmsis/src/dsp/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
    ../components/openmv-nxp/cmsis/src/dsp/CommonTables/: arm_common_tables.c
    ../components/openmv-nxp/cmsis/src/nn/PoolingFunctions/: arm_pool_q7_HWC_nonsquare.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/audio/: audio.c audio_pipe.c
    ../../../components/drivers/cputime/: cputime.c cputime_cortexm.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: board.c pins_imxrtevk106x.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../libraries/drivers/: drv_gpio.c drv_uart.c drv_hwtimer.c drv_rtc.c drv_spi.c drv_i2c.c drv_pwm.c drv_adc.c drv_sdio.c drv_norflash.c
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../../../components/dfs/filesystems/ramfs/: dfs_ramfs.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group LCD
    ../libraries/lcd/: seekfree_lcd_18tft.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/MIMXRT1062/MIMXRT1062/: system_MIMXRT1062.c fsl_flash.c
    ../libraries/MIMXRT1062/MIMXRT1062/drivers/: fsl_common.c fsl_clock.c fsl_cache.c fsl_gpio.c fsl_lpuart.c fsl_lpi2c.c fsl_lpspi.c fsl_gpt.c fsl_pwm.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_adc.c fsl_usdhc.c fsl_csi.c fsl_sai.c fsl_qtmr.c fsl_flexspi.c fsl_trng.c fsl_elcdif.c
    ../libraries/MIMXRT1062/MIMXRT1062/arm/: startup_MIMXRT1062.s
  group LVGL
    ../components/micropython-nxp/lib/lv_binding_micropython/gen/: lv_mpy.c
    ../components/micropython-nxp/lib/lv_binding_micropython/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../components/micropython-nxp/lib/lv_binding_micropython/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../components/micropython-nxp/lib/lv_binding_micropython/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../components/micropython-nxp/lib/lv_binding_micropython/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../components/micropython-nxp/lib/lv_binding_micropython/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../components/micropython-nxp/lib/lv_binding_micropython/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../components/micropython-nxp/lib/lv_binding_micropython/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../components/micropython-nxp/lib/lv_binding_micropython/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    ../components/micropython-nxp/lib/lv_binding_micropython/driver/nxp/: input.c lv_helper_nxp.c
    ../components/micropython-nxp/lib/lv_binding_micropython/driver/png/gen/: lodepng.c lodepng.pp.c mp_lodepng.c
  group MicroPython
    ../components/micropython-nxp/py/: argcheck.c asmarm.c asmbase.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitinlinextensa.c emitnarm.c emitnative.c emitnthumb.c emitnx64.c emitnx86.c emitnxtensa.c emitnxtensawin.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpy_scheduler.c mpz.c nativeglue.c nlr.c nlrpowerpc.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c omvdummy.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c profile.c pystack.c qstr.c reader.c repl.c ringbuf.c runtime.c runtime_utils.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
    ../components/micropython-nxp/lib/mp-readline/: readline.c
    ../components/micropython-nxp/lib/utils/: interrupt_char.c mpirq.c printf.c pyexec.c stdout_helpers.c sys_stdio_mphal.c
    ../components/micropython-nxp/extmod/: irqmap.c machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modled.c modonewire.c modrng.c modservo.c modubinascii.c moducryptolib.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduwebsocket.c moduzlib.c modwebrepl.c modwebsocket.c pyb_pin.c uos_dupterm.c utime_mphal.c vfs.c vfs_blockdev.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_posix.c vfs_posix_file.c vfs_reader.c virtpin.c
    ../components/micropython-nxp/port/: bufhelper.c frozen_mpy.c gccollect.c mpgetcharport.c mphalport.c mpputsnport.c mpthreadport.c mpy_main.c overlay_manager.c
    ../components/micropython-nxp/port/modules/: modffi.c modfile.c modmcu.c modnetwork.c modnetwork_wlan.c modpyb.c modrtthread.c moduos.c moduos_file.c modusocket.c modutils.c modutime.c
    ../components/micropython-nxp/port/modules/machine/: machine_adc.c machine_hw_i2c.c machine_hw_spi.c machine_lcd.c machine_pin.c machine_pwm.c machine_rtc.c machine_timer.c machine_uart.c machine_wdt.c modmachine.c
    ../components/micropython-nxp/port/modules/user/: moduserfunc.c
    ../components/micropython-nxp/lib/netutils/: netutils.c
    ../components/micropython-nxp/lib/timeutils/: timeutils.c
    ../components/micropython-nxp/drivers/bus/: softqspi.c softspi.c
    ../components/micropython-nxp/port/native/: easyflash_module.c native_module.c
    ../components/micropython-nxp/lib/aia_cmm/: cfg_mux_mgr.c
    ../components/micropython-nxp/lib/aia_doc/: doc_mgr.c
  group OMV
    ../components/openmv-nxp/: omv_main.c
    ../components/openmv-nxp/omv/img/: agast.c apriltag.c binary.c blob.c bmp.c clahe.c collections.c dmtx.c draw.c edge.c eye.c fast.c fft.c filter.c fmath.c font.c fsort.c gif.c haar.c hog.c hough.c imlib.c integral.c integral_mw.c invariant_tab.c jpeg.c kmeans.c lab_tab.c lbp.c line.c lsd.c mathop.c mjpeg.c orb.c phasecorrelation.c point.c pool.c ppm.c qrcode.c qsort.c rainbow_tab.c rectangle.c rgb2rgb_tab.c selective_search.c shadow_removal.c sincos_tab.c stats.c template.c xyz_tab.c yuv_tab.c zbar.c
    ../components/openmv-nxp/omv/nn/: nn.c
    ../components/openmv-nxp/omv/py/: py_helper.c py_sensor.c py_time.c py_image.c py_gif.c py_mjpeg.c py_nn.c py_winc.c py_nncu.c py_tf.c py_glow.c
    ../components/openmv-nxp/omv/: array.c fb_alloc.c ff_wrapper.c framebuffer.c ini.c mutex.c trace.c umm_malloc.c usbdbg.c xalloc.c pendsv.c
    ../components/openmv-nxp/nncu/: nncie_m4_m7_m33_sp_cmsisnn.lib
    ../components/openmv-nxp/libtf/cortex-m7/: libtf.lib libtf_person_detect_model_data.lib
  group Sensors
    ../libraries/sensors/: mt9v034.c ov2640.c ov5640.c ov7725.c ov9650.c drv_camera_uart.c SCC8660.lib
  group Touch
    ../../../components/drivers/touch/: touch.c
  group usb
    ../libraries/drivers/usb/phy/: usb_phy.c
    ../libraries/drivers/usb/app/: composite.c ring_buffer.c usb_device_cdc_acm.c usb_device_ch9.c usb_device_class.c usb_device_descriptor.c usb_device_msc.c usb_device_msc_ufi.c usbd_msc_storage.c virtual_com.c
    ../libraries/drivers/usb/device/: usb_device_dci.c usb_device_ehci.c
    ../libraries/drivers/usb/omv/: drv_usb_omv.c
  group xip
    xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
target debug_sram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.0.0
  cpu: as above
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\sdram.sct
  link misc: as above
